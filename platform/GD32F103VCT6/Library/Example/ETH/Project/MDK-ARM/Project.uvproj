# Keil uVision project Project.uvproj, settings and files
target GD32107C-EVAL (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GD32107C-EVAL +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32F10X_CL,
  c misc: --diag_suppress 236
  c include: ..\inc;..\..\..\..\Firmware\Peripherals\inc;..\..\..\..\Firmware\CMSIS;..\lwip-1.3.1\port;..\lwip-1.3.1\src\include;..\lwip-1.3.1\src\include\ipv4;..\lwip-1.3.1\src\include\lwip
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../src/: main.c netconf.c gd32f10x_it.c gd32f107.c HelloGigaDevice.c helloworld.c
  group GD32F10x_StdPeriph_Driver
    ../../../../Firmware/Peripherals/src/: gd32f10x_bkp.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group LwIP
    ../lwip-1.3.1/src/core/: dns.c dhcp.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../lwip-1.3.1/src/netif/: etharp.c
    ../lwip-1.3.1/src/api/: tcpip.c api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c
    ../lwip-1.3.1/port/: ethernetif.c
  group CMSIS
    ../../../../Firmware/CMSIS/: core_cm3.c system_gd32f10x.c
  group RVMDK
    ../../../../Firmware/: startup_gd32f10x_cl.s
  group doc
    ../src/: readme.txt
