# Keil uVision project Project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: GD32F10x GigaDevice
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\;..\..\Firmware\Peripherals\inc;..\..\Firmware\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../: main.c gd32f10x_it.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/: core_cm3.c system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../Firmware/Peripherals/src/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dma.c gd32f10x_eth.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_iwdg.c gd32f10x_mcudbg.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdg.c
  group Startup
    ../../Firmware/: startup_gd32f10x_cl.s
