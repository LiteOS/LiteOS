# Keil uVision project GD32F150R8T6_KEIL.uvprojx, settings and files
target HuaweiLiteOS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F150R8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.0.2
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GD32F150R8T6_KEIL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_0,GD32F130_150,GD32F150R8
  c include: ..\..\kernel\base\include;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\GD32F150R-EVAL;..\..\hal\GD32F1x0\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group platform/gd32f150r
    ../../platform/GD32F150R-EVAL/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group user
    ../../user/: main.c
software components: CMSIS:CORE 5.0.1, Device:GD32F1x0_EVAL 3.0.1, Device:GD32F1x0_StdPeripherals:ADC 3.0.1, Device:GD32F1x0_StdPeripherals:CAN 3.0.1, Device:GD32F1x0_StdPeripherals:CEC 3.0.1, Device:GD32F1x0_StdPeripherals:CMP 3.0.1, Device:GD32F1x0_StdPeripherals:CRC 3.0.1, Device:GD32F1x0_StdPeripherals:DAC 3.0.1, Device:GD32F1x0_StdPeripherals:DMA 3.0.1, Device:GD32F1x0_StdPeripherals:EXTI 3.0.1, Device:GD32F1x0_StdPeripherals:FMC 3.0.1, Device:GD32F1x0_StdPeripherals:FWDGT 3.0.1, Device:GD32F1x0_StdPeripherals:GPIO 3.0.1, Device:GD32F1x0_StdPeripherals:I2C 3.0.1, Device:GD32F1x0_StdPeripherals:IVREF 3.0.1, Device:GD32F1x0_StdPeripherals:MCUDBG 3.0.1, Device:GD32F1x0_StdPeripherals:MISC 3.0.1, Device:GD32F1x0_StdPeripherals:OPA 3.0.1, Device:GD32F1x0_StdPeripherals:PMU 3.0.1, Device:GD32F1x0_StdPeripherals:RCU 3.0.1, Device:GD32F1x0_StdPeripherals:RTC 3.0.1, Device:GD32F1x0_StdPeripherals:SLCD 3.0.1, Device:GD32F1x0_StdPeripherals:SPI_I2S 3.0.1, Device:GD32F1x0_StdPeripherals:SYSCFG 3.0.1, Device:GD32F1x0_StdPeripherals:TIMER 3.0.1, Device:GD32F1x0_StdPeripherals:TSI 3.0.1, Device:GD32F1x0_StdPeripherals:USART 3.0.1, Device:GD32F1x0_StdPeripherals:WWDGT 3.0.1, Device:GD32F1x0_libopt 3.0.1, Device:Startup 3.0.1
