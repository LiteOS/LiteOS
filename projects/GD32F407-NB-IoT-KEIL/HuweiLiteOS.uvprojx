# Keil uVision project HuweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F407ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.1
  cpu: IROM(0x08000000,0x300000) IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, GD32F407
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\link\keil;..\..\example\include;..\..\platform\GD32F407-NB-IoT;..\..\platform\GD32F407-NB-IoT\BSP\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\platform\GD32F407-NB-IoT\BSP\Utilities;..\..\platform\GD32F407-NB-IoT\BSP\Firmware\CMSIS;..\..\platform\GD32F407-NB-IoT\BSP\Template;..\..\platform\GD32F407-NB-IoT\BSP\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\..\platform\GD32F407-NB-IoT\BSP\Firmware\GD32F4xx_standard_peripheral\Include;..\..\platform\GD32F407-NB-IoT\BSP\Utilities\BSP\Include;..\..\platform\GD32F407-NB-IoT\BSP\Template\Application\Include;..\..\platform\GD32F407-NB-IoT\BSP\Utilities\HAL\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_dispatch_keil.s los_hw.c los_hw_tick.c los_hwi.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/gd32f407nbiot
    ../../platform/GD32F407-NB-IoT/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group bsp
    ../../platform/GD32F407-NB-IoT/BSP/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_misc.c
    ../../platform/GD32F407-NB-IoT/BSP/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../../platform/GD32F407-NB-IoT/BSP/Utilities/: gd32f407nb-iot_eval.c
    ../../platform/GD32F407-NB-IoT/BSP/Template/: gd32f4xx_it.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/GD32F407-NB-IoT/BSP/Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407.s
  group user
    ../../user/: main.c
