<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\HuaweiLiteOS_stm32f429.ewp</path>
  </project>
  <batchBuild/>
</workspace>


