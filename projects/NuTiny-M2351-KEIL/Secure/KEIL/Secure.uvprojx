# Keil uVision project Secure.uvprojx, settings and files
target Secure (6060000::V6.6::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: Secure
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: OneElfS=1 v6Lang=5
  c define: DEBUG_PORT = UART0
  c misc: -mfloat-abi=soft -Wno-documentation -Wno-reserved-id-macro
  c include: ..\..\..\..\hal\NTM2351\BSP\Library\CMSIS\Include;..\..\..\..\hal\NTM2351\BSP\Library\Device\Nuvoton\M2351\Include;..\..\..\..\hal\NTM2351\BSP\Library\StdDriver\inc;..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\secure.sct
  link misc: --import-cmse-lib-out ..\lib\nsclib_Secure.o
  group User
    ../: main.c
    ../../: partition_M2351.h
  group CMSIS
    ../../../../hal/NTM2351/BSP/Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
    ../../../../hal/NTM2351/BSP/Library/Device/Nuvoton/M2351/Source/: system_M2351.c
  group Library
    ../../../../hal/NTM2351/BSP/Library/StdDriver/src/: clk.c retarget.c
