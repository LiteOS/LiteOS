# Keil uVision project Nonsecure.uvprojx, settings and files
target Nonsecure (6060000::V6.6::.\ARMCLANG)
  device: M2351KIAAEES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.2
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x00080000) CPUTYPE("ARMV8MBL") TZ CLOCK(12000000) ESEL ELITTLE
  output: Nonsecure +hex
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  AfterMake: fromelf --text -c ".\Objects\@L.axf" --output ".\Objects\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=5
  c define: DEBUG_PORT=UART1_NS NUTINY_M2351 __CORTEX_M = 2
  c include: ..\..\Nonsecure;..\..\..\..\hal\NTM2351\BSP\Library\CMSIS\Include;..\..\..\..\hal\NTM2351\BSP\Library\Device\Nuvoton\M2351\Include;..\..\..\..\hal\NTM2351\BSP\Library\StdDriver\inc;..\..\..\..\example\include;..\..\..\..\kernel\base\include;..\..\..\..\kernel\include;..\..\..\..\kernel\link\keil;..\..\..\..\kernel\config;..\..\..\..\kernel\cpu\arm\cortex-m23;..\..\..\..\kernel\cmsis;..\..\..\..\platform\NuTiny-M2351
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: nonsecure.sct
  group user
    ../../../../user/: main.c
  group library
    ../../../../hal/NTM2351/BSP/Library/Device/Nuvoton/M2351/Source/: system_M2351.c
    ../../../../hal/NTM2351/BSP/Library/StdDriver/src/: can.c clk.c retarget.c uart.c sys.c
  group kernel
    ../../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../../../kernel/base/misc/: los_misc.c
  group cpu/m23
    ../../../../kernel/cpu/arm/cortex-m23/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../../../kernel/config/: los_config.c
  group platform/NuTiny-M2351
    ../../../../platform/NuTiny-M2351/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
    ../../Secure/lib/: nsclib_Secure.o
  group example
    ../../../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c los_xmodem.c
  group startup
    ../../../../hal/NTM2351/BSP/Library/Device/Nuvoton/M2351/Source/ARM/: startup_M2351.s
  group cmsis
    ../../../../kernel/cmsis/: cmsis_liteos.c
