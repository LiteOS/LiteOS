# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_0 LOS_MM32L073PF
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\cmsis;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m0;..\..\kernel\link\keil;..\..\example\include;..\..\platform\MM32L073PF;..\..\platform\MM32L073PF\uart;..\..\platform\MM32L073PF\include;..\..\platform\MM32L073PF\sysclk;..\..\platform\MM32L073PF\key;..\..\platform\MM32L073PF\led
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m0
    ../../kernel/cpu/arm/cortex-m0/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group platform/mm32l073pf
    ../../platform/MM32L073PF/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group platfom/mm32l073pf/driver
    ../../platform/MM32L073PF/uart/: uart.c
    ../../platform/MM32L073PF/sysclk/: system_MM32L0xx.c
    ../../platform/MM32L073PF/key/: key.c
    ../../platform/MM32L073PF/led/: led.c
  group user
    ../../user/: main.c
  group startup
    ../../platform/MM32L073PF/: los_startup_keil.s
