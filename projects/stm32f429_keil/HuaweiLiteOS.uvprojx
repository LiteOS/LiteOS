# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\platform\include\keil;..\..\platform\bsp\sample\config;..\..\platform\cpu\arm\cortex-m4;..\..\api_example\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\startup\STM32F429I-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group platform
    ../../platform/bsp/sample/config/: los_config.c
    ../../platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c
  group startup
    ./startup/: los_dispatch.s los_vendor.s
