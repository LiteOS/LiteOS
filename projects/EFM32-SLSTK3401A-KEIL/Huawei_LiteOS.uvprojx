# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target Huawei_LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: EFM32PG1B200F256GM32 Silicon Labs
  pack: Keil.EFM32PG1B_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_1 EFM32PG1B200F256GM48
  c include: ..\..\example\include;..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\cmsis;..\..\example\include;..\..\kernel\link\keil;..\..\platform\EFM32-SLSTK3401A;..\..\platform\EFM32-SLSTK3401A\include;..\..\hal\EMF32\CMSIS;..\..\hal\EMF32\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group library
    ../../hal/EMF32/FWlib/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c em_core.c
  group platform/slstk3401a
    ../../platform/EFM32-SLSTK3401A/: los_bsp_key.c los_bsp_led.c system_efm32pg1b.c los_bsp_uart.c los_bsp_adapter.c
    ../../platform/EFM32-SLSTK3401A/bsp/: bsp_stk_leds.c retargetvirtual.c
  group startup
    ../../platform/EFM32-SLSTK3401A/: startup_efm32pg1b_keil.s
  group user
    ../../user/: main.c
