# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: MM32L373PS MindMotion
  pack: MindMotion.MM32L3xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_1,USE_STDPERIPH_DRIVER
  c include: ..\..\platform\MM32L373\SYSTEM\delay;..\..\platform\MM32L373\HARDWARE\LED;..\..\platform\MM32L373\HARDWARE\KEY;..\..\platform\MM32L373\HARDWARE\EXTI;..\..\platform\MM32L373\HARDWARE\UART;..\..\platform\MM32L373\Device\CMSIS\KEIL_CORE;..\..\platform\MM32L373\Device\MM32L3xx\HAL_lib\inc;..\..\platform\MM32L373\Device\MM32L3xx\Include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m3;..\..\example\include;..\..\platform\MM32L373;..\..\platform\MM32L373\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/mm32l373
    ../../platform/MM32L373/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group user
    ../../user/: main.c
  group hardware
    ../../platform/MM32L373/HARDWARE/LED/: led.c
    ../../platform/MM32L373/HARDWARE/KEY/: key.c
    ../../platform/MM32L373/HARDWARE/UART/: uart.c
  group system
    ../../platform/MM32L373/Device/MM32L3xx/Source/: system_MM32L3xx.c
    ../../platform/MM32L373/SYSTEM/delay/: delay.c
  group hal_lib
    ../../platform/MM32L373/Device/MM32L3xx/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dac.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/MM32L373/Device/MM32L3xx/Source/KEIL_StartAsm/: startup_MM32L3xx.s
