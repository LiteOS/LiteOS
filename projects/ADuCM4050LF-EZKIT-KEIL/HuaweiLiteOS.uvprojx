# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ADuCM4050 Analog Devices
  pack: AnalogDevices.ADuCM4x50_DFP.1.0.0
  cpu: IROM(0x00000000,0x7F000) IRAM(0x20000000,0x04000) IRAM2(0x20040000,0x14000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\link\keil;..\..\platform\ADuCM4050LF-EZKIT;..\..\example\include;D:\Keil_v5\ARM\Pack\AnalogDevices\ADuCM4x50_DFP\1.0.0\Include\drivers\pwr;D:\Keil_v5\ARM\Pack\AnalogDevices\ADuCM4x50_DFP\1.0.0\Include\drivers\uart;D:\Keil_v5\ARM\Pack\AnalogDevices\ADuCM4x50_DFP\1.0.0\Include\drivers\gpio
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7f000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x14000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group cpu/cm4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group platform/aducm4050
    ../../platform/ADuCM4050LF-EZKIT/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group user
    ../../user/: main.c
software components: CMSIS:CORE 4.3.0, Device:Drivers:DMA 1.0.0, Device:Drivers:Flash 1.0.0, Device:Drivers:GPIO 1.0.0, Device:Drivers:I2C 1.0.0, Device:Drivers:Power 1.0.0, Device:Drivers:SPI 1.0.0, Device:Drivers:UART 1.0.0, Device:Global Configuration 1.0.0, Device:Startup 1.0.0
