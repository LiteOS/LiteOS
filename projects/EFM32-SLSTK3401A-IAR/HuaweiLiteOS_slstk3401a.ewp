# IAR project HuaweiLiteOS_slstk3401a.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32PG1B200F256GM48 SiliconLaboratories EFM32PG1B200F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RAM_SIZE_LEVEL_1; EFM32PG1B200F256GM48
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m4; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\EFM32-SLSTK3401A; ..\..\platform\EFM32-SLSTK3401A\include; ..\..\hal\EMF32\CMSIS; ..\..\hal\EMF32\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS_slstk3401a.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS_slstk3401a.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\SiliconLaboratories\EFM32PG1B200F256.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/library
    ../../hal/EMF32/FWlib/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group Huawei_LiteOS/platform/slstk3401a
    ../../platform/EFM32-SLSTK3401A/bsp/: bsp_stk_leds.c retargetvirtual.c
    ../../platform/EFM32-SLSTK3401A/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c system_efm32pg1b.c
  group Huawei_LiteOS/startup
    ../../platform/EFM32-SLSTK3401A/: startup_efm32pg1b_iar.s
  group Huawei_LiteOS/user
    ../../user/: main.c
