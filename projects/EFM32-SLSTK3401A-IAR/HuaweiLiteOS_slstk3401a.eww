<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HuaweiLiteOS_slstk3401a.ewp</path>
    </project>
    <batchBuild />
</workspace>
