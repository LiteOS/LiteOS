# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; LOS_STM32F103RB; RAM_SIZE_LEVEL_0
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m3; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\STM32F103RB-NUCLEO; ..\..\platform\STM32F103RB-NUCLEO\Libraries\CMSIS; ..\..\platform\STM32F103RB-NUCLEO\Libraries\FWlib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
    ../../platform/STM32F103RB-NUCLEO/Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/libraries
    ../../platform/STM32F103RB-NUCLEO/Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_it.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Huawei_LiteOS/platform/stm32f103rb
    ../../platform/STM32F103RB-NUCLEO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group Huawei_LiteOS/startup
    ../../platform/STM32F103RB-NUCLEO/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../user/: main.c
