# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ATSAMD21J18A Atmel
  pack: Keil.SAMD21_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_2,LOS_ATSAMD21_XPRO LOS_KEIL_COMPILE
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\cmsis;..\..\kernel\include;..\..\platform\ATSAMD21-XPRO;..\..\kernel\cpu\arm\cortex-m0plus;..\..\kernel\link\keil;..\..\kernel\config;..\..\platform\ATSAMD21-XPRO\AMD21
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/atsamd21
    ../../platform/ATSAMD21-XPRO/: los_bsp_adapter.c los_bsp_key.c los_bsp_uart.c los_bsp_led.c uart.c los_bsp_clock.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/ATSAMD21-XPRO/: los_startup_keil.s
  group user
    ../../user/: main.c
  group cpu/m0plus
    ../../kernel/cpu/arm/cortex-m0plus/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
