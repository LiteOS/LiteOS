# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L053R8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.1
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_0
  c include: ..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\kernel\cpu\arm\cortex-m0+;..\..\example\include;..\..\platform\STM32L053_Nucleo;..\..\BSP\STM32L053R8Tx\Inc;..\..\BSP\STM32L053R8Tx\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\BSP\STM32L053R8Tx\Drivers\STM32L0xx_HAL_Drive\Inc\Legacy;..\..\BSP\STM32L053R8Tx\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\BSP\STM32L053R8Tx\Drivers\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m0+
    ../../kernel/cpu/arm/cortex-m0+/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/stm32L053r8
    ../../platform/STM32L053_Nucleo/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group startup
    ../../platform/STM32L053_NUCLEO/: startup_stm32l053xx.s
  group user
    ../../user/: main.c
