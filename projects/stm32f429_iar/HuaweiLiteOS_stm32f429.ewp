# IAR project HuaweiLiteOS_stm32f429.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\platform\include\iar; ..\..\platform\bsp\config; ..\..\platform\cpu\arm\cortex-m4; ..\..\example\include; ..\..\kernel\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS_stm32f429.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS_stm32f429.out
  ILINK.IlinkIcfFile: startup\stm32f429xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/app
    ../../App/: main.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/platform/bsp
    ../../platform/bsp/config/: los_bsp_adapter.c los_config.c
  group Huawei_LiteOS/platform/cpu
    ../../platform/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/startup
    startup/: los_dispatch.s los_vendor.s
