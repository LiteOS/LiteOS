# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: LOS_STM32F746ZG; STM32F746xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m4; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\STM32F746ZG_NUCLEO; ..\..\hal\STM32F7xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m7
    ../../kernel/cpu/arm/cortex-m7/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/libraries
    ../../hal/STM32F7xx/FWlib/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
    ../../platform/STM32F746ZG_NUCLEO/: stm32f7xx_nucleo_144.c
    ../../hal/STM32F7xx/CMSIS/: system_stm32f7xx.c
  group Huawei_LiteOS/platform/stm32f746zg
    ../../platform/STM32F746ZG_NUCLEO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c
  group Huawei_LiteOS/startup
    ../../platform/STM32F746ZG_NUCLEO/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../user/: main.c
