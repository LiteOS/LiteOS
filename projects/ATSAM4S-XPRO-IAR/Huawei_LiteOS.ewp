# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4SD32C Atmel ATSAM4SD32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: ATSAM4S_XPRO; __SAM4SD32C__; __ALIGNED
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\kernel\include; ..\..\kernel\base\include; ..\..\kernel\config; ..\..\kernel\cpu\arm\cortex-m3; ..\..\kernel\cmsis; ..\..\example\include; ..\..\kernel\link\iar; ..\..\platform\ATSAM4S-XPRO; ..\..\hal\ATMEL\SAM4S; ..\..\hal\ATMEL\SAM4S\pio; ..\..\hal\ATMEL\SAM4S\instance; ..\..\hal\ATMEL\SAM4S\component
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.hex
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Huawei_LiteOS/cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group Huawei_LiteOS/config
    ../../kernel/config/: los_config.c
  group Huawei_LiteOS/cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group Huawei_LiteOS/example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group Huawei_LiteOS/kernel/base
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group Huawei_LiteOS/platform/ATSAM4S-XPRO
    ../../platform/ATSAM4S-XPRO/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c system_SAM4S.c
  group Huawei_LiteOS/startup
    ../../platform/ATSAM4S-XPRO/: los_startup_iar.s
  group Huawei_LiteOS/user
    ../../user/: main.c
