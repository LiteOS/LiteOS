# Keil uVision project gd32f190R8T6.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F190R8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gd32f190R8T6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RAM_SIZE_LEVEL_0,GD32F190R8
  c include: ..\..\kernel\include;..\..\kernel\base\include;..\..\kernel\cmsis;..\..\platform\include\keil;..\..\platform\bsp\config;..\..\platform\cpu\arm\cortex-m3;..\..\example\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c
  group platform/bsp
    ../../platform/bsp/config/: los_bsp_adapter.c los_config.c
  group platform/cpu
    ../../platform/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c
  group startup
    ./startup/: los_dispatch.s los_vendor.s
  group app
    ../../App/: main.c
