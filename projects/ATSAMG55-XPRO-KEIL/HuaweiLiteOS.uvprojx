# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ATSAMG55J19 Atmel
  pack: Keil.SAMG_DFP.1.1.0
  cpu: IROM(0x00400000,0x80000) IRAM(0x20000000,0x28000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\example\include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\link\keil;..\..\kernel\config;..\..\kernel\cpu\arm\cortex-m4;..\..\kernel\cmsis;..\..\user;..\..\platform\ATSAMG55-XPRO
  library: MicroLIB
  memory RVCT4: ROM 0x400000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m4
    ../../kernel/cpu/arm/cortex-m4/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group platform/atmsamg55
    ../../platform/ATSAMG55-XPRO/: los_bsp_adapter.c los_bsp_led.c los_bsp_key.c los_bsp_uart.c
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group user
    ../../user/: main.c
software components: CMSIS:CORE 4.3.0, Board Support:Buttons 1.0.0, Board Support:LED 1.0.0, Device:Startup 1.0.0
