# IAR project HuaweiLiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32GG990F1024 SiliconLaboratories EFM32GG990F1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: LOS_EFM32GG_STK3700; EFM32GG990F1024
  ICCARM.CCIncludePath2: ..\..\example\include; ..\..\hal\EMF32\Include; ..\..\hal\EMF32\CMSIS; ..\..\kernel\base\include; ..\..\kernel\include; ..\..\kernel\link\iar; ..\..\kernel\config; ..\..\kernel\cmsis; ..\..\kernel\cpu\arm\cortex-m3; ..\..\platform\EFM32-STK3700; ..\..\platform\EFM32-STK3700\include; ..\..\example\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HuaweiLiteOS.bin
  ILINK.IlinkOutputFile: HuaweiLiteOS.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group config
    ../../kernel/config/: los_config.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_dispatch_iar.s los_hw.c los_hw_tick.c los_hwi.c
  group example
    ../../example/api/: los_api_dynamic_mem.c los_api_event.c los_api_fs.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_cmsis_main.c los_demo_entry.c los_inspect_entry.c
  group kernel
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group library
    ../../hal/EMF32/FWlib/: em_assert.c em_cmu.c em_ebi.c em_emu.c em_gpio.c em_system.c em_usart.c
  group platform/stk3700
    ../../platform/EFM32-STK3700/bsp/: bsp_stk_leds.c
    ../../platform/EFM32-STK3700/: los_bsp_adapter.c los_bsp_key.c los_bsp_led.c los_bsp_uart.c system_efm32gg.c
  group startup
    ../../platform/EFM32-STK3700/: los_startup_iar.s
  group user
    ../../user/: main.c
