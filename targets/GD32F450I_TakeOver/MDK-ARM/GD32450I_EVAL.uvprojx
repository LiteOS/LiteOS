# Keil uVision project GD32450I_EVAL.uvprojx, settings and files
target GD32450I_EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F450IG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.4
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x08000000-0x080FFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: GD32450I_EVAL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F450
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\..\..\Library\Firmware\GD32F4xx_standard_peripheral\Include;..\..\..\Library\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\..\Library\Utilities;..\;..\LiteOS\arch\arm\arm-m\include;..\LiteOS\cmsis;..\LiteOS\cmsis\1.0;..\LiteOS\cmsis\2.0;..\LiteOS\kernel\base\include;..\LiteOS\kernel\extended\include;..\LiteOS\kernel\include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.6.0\CMSIS\Include;..\LiteOS\OS_CONFIG_TakeOver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\GD32F450IG-LiteOS.sct
  group Application
    ../: main.c gd32f4xx_it.c systick.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group GD32F4xx_Peripherals
    ../../../Library/Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group GD32F4xx_EVAL
    ../../../Library/Utilities/: gd32f450i_eval.c
  group Startup
    ../LiteOS/: los_startup_keil.s
  group Doc
    ../: readme.txt
  group LiteOS/cmsis
    ../LiteOS/cmsis/: cmsis_liteos.c
  group LiteOS/kernel
    ../LiteOS/kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../LiteOS/kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../LiteOS/kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../LiteOS/kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../LiteOS/kernel/base/mem/membox/: los_membox.c
    ../LiteOS/kernel/base/misc/: los_misc.c
    ../LiteOS/kernel/base/om/: los_err.c
    ../LiteOS/kernel/extended/tickless/: los_tickless.c
    ../LiteOS/kernel/: los_init.c
  group LiteOS/arch
    ../LiteOS/arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../LiteOS/arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group LiteOS/config_takeover
    ../LiteOS/OS_CONFIG_TakeOver/: los_builddef.h los_printf.h target_config.h
