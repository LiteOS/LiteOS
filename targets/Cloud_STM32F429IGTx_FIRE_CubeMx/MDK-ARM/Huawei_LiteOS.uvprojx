# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target Huawei_LiteOS (ARM-ADS)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Huawei_LiteOS
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,WITH_AT_FRAMEWORK,USE_NB_NEUL95,LWM2M_CLIENT_MODE,LWM2M_LITTLE_ENDIAN,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,CONFIG_FEATURE_FOTA,AT_NBONLY
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\OS_CONFIG;..\..\..\include\liteos;..\..\..\include;..\..\..\include\arch\arm-m;..\..\..\demos;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\connectivity\lwm2m\examples\shared
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr_ex.c
  group LiteOS/CMSIS
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group LiteOS/Kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/: los_init.c
  group LiteOS/Arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group AT_Frame USE NB_IOT_BC95
    ../../../components/connectivity/nb_iot/: los_nb_api.c
    ../../../components/net/at_device_nb/bc95/: bc95.c
    ../../../components/net/at_frame/: at_api_interface.c atadapter.c
  group Application/User
    ../Src/: usart.c stm32f4xx_hal_msp.c main.c gpio.c stm32f4xx_it.c at_hal.c hal_rng.c fota_port.c hal_flash.c hal_iwdg.c hal_spi_flash.c sys_init.c dwt.c
    ../../../demos/agenttiny_lwm2m/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
    ../../../osdepends/liteos/: atiny_adapter.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Agenttiny
    ../../../components/connectivity/agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c atiny_rpt.c connection.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c util_timer.c
    ../../../components/connectivity/agent_tiny/firmware_update/: atiny_fota_manager.c atiny_fota_state.c atiny_update_info.c firmware_update.c
  group Lwm2m
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
  group FOTA
    ../../../components/ota/fota/fota_package_storage_device/: fota_firmware_writer.c fota_package_checksum.c fota_package_head.c fota_package_storage_device.c
    ../../../components/ota/fota/ota/: ota.c ota_default.c
    ../../../components/ota/fota/utility/: ota_crc.c ota_sha256.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
software components: CMSIS:CORE 4.3.0
