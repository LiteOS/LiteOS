# Keil uVision project STM32F103VTET6_INDUSTRIAL.uvprojx, settings and files
target STM32F103VTET6_INDUSTRIAL (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103VTET6_INDUSTRIAL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../../Inc;../../Drivers/STM32F1xx_HAL_Driver/Inc;../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_uart.c
  group Application/User
    ../../Src/: usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c gpio.c main.c
  group Drivers/CMSIS
    ../..//Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
