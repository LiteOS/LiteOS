# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,LOS_STM32F103ZE,LOS_KERNEL_DEBUG_OUT,CIS_EMBED
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m3;..\..\..\examples\include;..\Drivers\STM32F10x_Drivers\STM32F10x_StdPeriph_Driver\inc;..\Src;..\..\..\thirdparty\OneNET\NBIOT\ciscore;..\..\..\thirdparty\OneNET\NBIOT\adapter;..\..\..\thirdparty\OneNET\NBIOT\device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\STM32F103RE-LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../User/: main.c cis_sample_entry.c cis_sample_entry1.c
  group src
    ../Inc/: stm32f10x_conf.h
    ../Src/: sys_init.c stm32f10x_it.c los_bsp_adapter.c usart.c los_bsp_key.c los_bsp_led.c
    ../Drivers/STM32F10x_Drivers/: i2c.c sht20.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group examples
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group Drivers/STM32F10x
    ../Drivers/STM32F10x_Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drivers/cmsis
    ../Drivers/STM32F10x_Drivers/cmsis/: system_stm32f10x.c
  group NBIOT/core
    ../../../thirdparty/OneNET/NBIOT/ciscore/: ciscore.lib
  group NBIOT/adapter
    ../../../thirdparty/OneNET/NBIOT/adapter/: cis_if_net.c cis_if_sys.c
  group NBIOT/device
    ../../../thirdparty/OneNET/NBIOT/device/: M5310.c os-api.c usart3.c
software components: CMSIS:CORE 5.0.1
