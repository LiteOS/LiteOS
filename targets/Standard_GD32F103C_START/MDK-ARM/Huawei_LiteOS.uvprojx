# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F103VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_HD,NDEBUG
  c misc: --diag_suppress=186
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m3;..\..\..\examples\include;..\Drivers\GD32F10x_standard_peripheral\Include;..\Hardware\Inc;..\..\..\arch\arm\common\cmsis
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\GD32F103VC_LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../src/: main.c sys_init.c system_gd32f10x.c dwt.c led.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
  group Drivers/GD32F10x_standard_peripheral
    ../Drivers/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group example
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
