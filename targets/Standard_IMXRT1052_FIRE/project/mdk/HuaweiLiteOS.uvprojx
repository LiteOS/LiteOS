# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052DVL6B,XIP_EXTERNAL_FLASH=1, XIP_BOOT_HEADER_ENABLE =1,XIP_BOOT_HEADER_DCD_ENABLE =1,PRINTF_FLOAT_ENABLE=1, SCANF_FLOAT_ENABLE=1, PRINTF_ADVANCED_ENABLE=1, SCANF_ADVANCED_ENABLE=1
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186,1,47,177,223,1295
  c include: ..\..\libraries\CMSIS\Include;..\..\libraries\drivers;..\..\libraries\utilities;..\..\libraries\utilities\str;..\..\libraries\utilities\log;..\..\libraries\utilities\io;..\..\libraries\xip;..\..\user;..\..\user\bsp;..\..\..\..\components\cmsis;..\..\..\..\components\cmsis\1.0;..\..\..\..\components\cmsis\2.0;..\..\..\..\kernel\base\include;..\..\..\..\kernel\extended\include;..\..\..\..\kernel\include;..\..\..\..\arch\arm\arm-m\include;..\..\OS_CONFIG
  asm define: __STARTUP_INITIALIZE_NONCACHEDATA
  library: MicroLIB
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\MIMXRT1052xxxxx_nor_txt_ram.scf
  link misc: --keep=*(.boot_hdr.conf)
--keep=*(.boot_hdr.ivt)
  group CMSIS
    ../../libraries/: system_MIMXRT1052.c system_MIMXRT1052.h
  group startup
    ./: startup_MIMXRT1052.s
  group drivers
    ../../libraries/drivers/: fsl_clock.c fsl_gpio.c fsl_lpuart.c fsl_common.c fsl_iomuxc.h
  group utilities
    ../../libraries/utilities/: fsl_assert.c fsl_notifier.c fsl_shell.c fsl_sbrk.c fsl_debug_console.c
    ../../libraries/utilities/str/: fsl_str.c
    ../../libraries/utilities/log/: fsl_log.c
    ../../libraries/utilities/io/: fsl_io.c
  group board
    ../../user/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group user
    ../../user/: main.c
    ../../user/bsp/led/: bsp_led.c
  group xip
    ../../user/xip/: fire_imxrt1052_sdram_ini_dcd.c fire_imxrt1052_spiflash_config.c fsl_flexspi_nor_boot.c
  group liteos/cmsis
    ../../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../../kernel/base/mem/membox/: los_membox.c
    ../../../../kernel/base/misc/: los_misc.c
    ../../../../kernel/base/om/: los_err.c
    ../../../../kernel/extended/tickless/: los_tickless.c
    ../../../../kernel/: los_init.c
  group liteos/arch
    ../../../../arch/arm/arm-m/cortex-m7/keil/: los_dispatch_keil.S
    ../../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
