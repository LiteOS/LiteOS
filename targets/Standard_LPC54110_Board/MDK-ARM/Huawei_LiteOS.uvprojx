# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_LPC54114J256BD64_cm4,LOS_KERNEL_DEBUG_OUT,NDEBUG
  c misc: --diag_suppress=66
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\..\..\examples\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\common\cmsis;..\Drivers\LPC54114;..\Drivers\LPC54114\drivers;..\Drivers\LPC54114\utilities;..\Drivers\LPC54114\utilities\log;..\Drivers\LPC54114\utilities\io;..\Drivers\LPC54114\utilities\str
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\Drivers\LPC54114\arm\LPC54114J256_cm4.scf
  group startup
    ../Drivers/LPC54114/arm/: startup_LPC54114_cm4.s
  group user
    ../Src/: main.c sys_init.c board.c clock_config.c pin_mux.c
    ../Drivers/LPC54114/: system_LPC54114_cm4.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group Drivers/LPC54114
    ../Drivers/LPC54114/arm/: keil_lib_power.lib
    ../Drivers/LPC54114/drivers/: fsl_clock.c fsl_common.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flexcomm.c fsl_power.c fsl_reset.c fsl_usart.c fsl_gpio.c
  group Drivers/utilities
    ../Drivers/LPC54114/utilities/: fsl_debug_console.c fsl_assert.c
    ../Drivers/LPC54114/utilities/log/: fsl_log.c
    ../Drivers/LPC54114/utilities/io/: fsl_io.c
    ../Drivers/LPC54114/utilities/str/: fsl_str.c
