# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CPU_LPC54114J256BD64_cm4; LOS_KERNEL_DEBUG_OUT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Core\Include; ..\Inc; ..\..\..\components\cmsis; ..\..\..\components\cmsis\1.0; ..\..\..\components\cmsis\2.0; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\examples\include; ..\..\..\kernel\extended\include; ..\Drivers\LPC54114; ..\Drivers\LPC54114\drivers; ..\Drivers\LPC54114\utilities; ..\Drivers\LPC54114\utilities\log; ..\Drivers\LPC54114\utilities\io; ..\Drivers\LPC54114\utilities\str
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: ..\Drivers\LPC54114\iar\LPC54114J256_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/LPC54114
    ../Drivers/LPC54114/drivers/: fsl_clock.c fsl_common.c fsl_flexcomm.c fsl_gpio.c fsl_power.c fsl_reset.c fsl_usart.c
    ../Drivers/LPC54114/iar/: iar_lib_power.a
  group Drivers/utilities
    ../Drivers/LPC54114/utilities/: fsl_debug_console.c
    ../Drivers/LPC54114/utilities/io/: fsl_io.c
    ../Drivers/LPC54114/utilities/log/: fsl_log.c
    ../Drivers/LPC54114/utilities/str/: fsl_str.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group starup
    ../Drivers/LPC54114/iar/: startup_LPC54114_cm4.s
  group user
    ../Src/: board.c clock_config.c main.c pin_mux.c sys_init.c
    ../Drivers/LPC54114/: system_LPC54114_cm4.c
