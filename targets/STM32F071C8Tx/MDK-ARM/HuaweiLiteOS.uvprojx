# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target LiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F071C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LOS_KERNEL_DEBUG_OUT,STM32F071xB
  c include: ..\..\..\kernel\base\include;..\..\..\kernel\include;..\OS_CONFIG;..\Inc;..\..\..\arch\arm\arm-m\include;..\..\..\kernel\extended\include;..\..\..\examples\include;C:\Keil_v5\ARM\PACK\ARM\CMSIS\5.3.0\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\STM32F071C8-LiteOS.sct
  group liteos\kernel\base\core
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
  group liteos\kernel\base\ipc
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
  group liteos\kernel\base\mem\bestfit_little
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_membox.c los_memcheck.c los_memory.c
  group liteos\kernel\base\mem\common
    ../../../kernel/base/mem/common/: los_memstat.c los_slab.c los_slabmem.c
  group liteos\kernel\base\misc
    ../../../kernel/base/misc/: los_misc.c
  group liteos\kernel\base\om
    ../../../kernel/base/om/: los_err.c
  group liteos\kernel\extended\tickless
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos\kernel
    ../../../kernel/: los_init.c
  group MDK-ARM
    ./: los_startup_keil.s
  group liteos\examples\api
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group Src
    ../Src/: main.c system_stm32f0xx.c
  group liteos\arch\arm\arm-m\cortex-m0\keil
    ../../../arch/arm/arm-m/cortex-m0/keil/: los_dispatch_keil.S
  group liteos\arch\arm\arm-m\src
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
