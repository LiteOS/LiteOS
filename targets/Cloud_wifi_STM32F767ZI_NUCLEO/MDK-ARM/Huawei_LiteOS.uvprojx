# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F767ZITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,LOS_KERNEL_DEBUG_OUT,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,WITH_LWIP,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_DTLS,CONFIG_FEATURE_FOTA,USE_AT_FRAMEWORK,USE_ESP8266_SPI
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m7;..\..\..\examples\include;..\Drivers\STM32F7xx_HAL_Driver\Inc;..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;..\..\..\components\net\lwip-2.0.3\src\include;..\..\..\components\net\lwip_port;..\..\..\components\net\lwip_port\OS;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include\mbedtls;..\..\..\components\connectivity\agent_tiny\comm\include;..\..\..\components\connectivity\agent_tiny\lwm2m_client;..\..\..\components\connectivity\agent_tiny\examples;..\Drivers\osadapter;..\Hardware\Inc;..\..\..\drivers\devices\wifi\esp8266_anylink_spi;..\..\..\drivers\devices\wifi\esp8266_anylink_spi\Cortex-M7_lib;..\..\..\components\fota\fota_package_storage_device;..\..\..\components\connectivity\agent_tiny\firmware_update;..\..\..\components\connectivity\agent_tiny\lwm2m_client\fota;..\..\..\components\fota\ota;..\..\..\components\fota\utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\STM32F746ZG-LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../Src/: main.c system_stm32f7xx.c sys_init.c usart.c dwt.c fota_port.c board.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m7/keil/: los_dispatch_keil.S
  group examples
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_flash.c stm32f7xx_hal_pwr.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_rng.c stm32f7xx_hal_iwdg.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group er-coap
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
  group os_adapter
    ../Drivers/osadapter/: atiny_adapter.c atiny_socket.c
  group atiny_tiny
    ../../../components/connectivity/agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c atiny_rpt.c commandline.c connection.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c
    ../../../components/connectivity/agent_tiny/firmware_update/: firmware_update.c
    ../../../components/connectivity/agent_tiny/lwm2m_client/fota/: atiny_fota_manager.c atiny_fota_state.c atiny_update_info.c
  group agent_demo
    ../../../components/connectivity/agent_tiny/examples/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
  group Hardware
    ../Hardware/Src/: hal_rng.c hal_flash.c hal_iwdg.c hal_spi_flash.c
  group drivers/devices/wifi/esp8266_anylink_spi
    ../../../drivers/devices/wifi/esp8266_anylink_spi/: M8266_WIFI_SPI_IF.c
    ../../../drivers/devices/wifi/esp8266_anylink_spi/Cortex-M7_lib/: M8266_WIFI_SPI.c M8266WIFIDrv_STM32F7xx.lib M8266_WIFI_SPI_HAL.c
  group fota_package_storage_device
    ../../../components/fota/fota_package_storage_device/: fota_firmware_writer.c fota_package_head.c fota_package_storage_device.c fota_package_checksum.c
  group fota/ota
    ../../../components/fota/ota/: ota.c ota_default.c
  group fota/utility
    ../../../components/fota/utility/: ota_crc.c ota_sha256.c
software components: CMSIS:CORE 5.0.1
