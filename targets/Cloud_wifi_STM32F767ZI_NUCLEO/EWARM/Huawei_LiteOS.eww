<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Huawei_LiteOS.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>all</name>
            <member>
                <project>gpio_led_output</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>gpio_led_output</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Release</name>
            <member>
                <project>gpio_led_output</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>Debug</name>
            <member>
                <project>gpio_led_output</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
