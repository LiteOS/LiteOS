# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.2.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: liteos
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Drivers\CMSIS\Device\NUC472_442\Include;..\Drivers\StdDriver\Inc;..\Drivers\CMSIS\include;..\Inc;..\..\..\arch\arm\arm-m\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\kernel\include;..\..\..\kernel\base\core;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\common\cmsis;..\..\..\components\cmsis;..\..\..\components\cmsis\2.0;..\OS_CONFIG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../Drivers/CMSIS/Device/NUC472_442/Source/Templates/: system_NUC472_442.c
    ../Drivers/CMSIS/Device/NUC472_442/Source/Templates/arm/: startup_NUC472_442.s
  group user
    ../Src/: main.c sys_init.c usart.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group Drivers
    ../Drivers/StdDriver/Src/: acmp.c adc.c can.c cap.c clk.c crc.c crypto.c eadc.c ebi.c emac.c epwm.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c retarget.c rtc.c sc.c scuart.c sd.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
