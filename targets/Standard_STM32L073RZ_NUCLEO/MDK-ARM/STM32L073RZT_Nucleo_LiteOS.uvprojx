# Keil uVision project STM32L073RZT_Nucleo_LiteOS.uvprojx, settings and files
target STM32L073RZT_Nucleo_LiteOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073RZT_Nucleo_LiteOS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L073xx
  c include: ../Inc;../Drivers/STM32L0xx_HAL_Driver/Inc;../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../Drivers/CMSIS/Include;..\..\..\arch\arm\arm-m\include;..\..\..\kernel\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\examples\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c gpio.c usart.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l0xx.c
  group Middleware/LiteOS/arch
    ../../../arch/arm/arm-m/cortex-m0/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group Middleware/LiteOS/kernel
    ../../../kernel/: los_init.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group Middleware/LiteOS/examples
    ../../../examples/api/: los_inspect_entry.c los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c
software components: CMSIS:CORE 4.3.0
