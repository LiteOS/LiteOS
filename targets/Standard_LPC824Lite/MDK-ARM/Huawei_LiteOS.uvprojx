# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: NXP.LPC824_DFP.10.0.3
  cpu: IRAM(0x10000000,0x2000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_LPC824M201JHI33,LOS_KERNEL_DEBUG_OUT,NDEBUG
  c include: ..\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\..\..\examples\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\common\cmsis;..\Drivers\LPC824
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\LPC824_flash.scf
  group startup
    ./: startup_LPC824.s
  group user
    ../Src/: main.c system_LPC824.c board.c clock_config.c sys_init.c usart.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m0/keil/: los_dispatch_keil.S
  group Drivers/LPC824
    ../Drivers/LPC824/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_reset.c fsl_swm.c fsl_syscon.c fsl_usart.c
