# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CPU_LPC824M201JHI33; LOS_KERNEL_DEBUG_OUT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Core\Include; ..\Inc; ..\..\..\components\cmsis; ..\..\..\components\cmsis\1.0; ..\..\..\components\cmsis\2.0; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\examples\include; ..\Drivers\LPC824; ..\..\..\kernel\extended\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: LPC824M201-LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/LPC824
    ../Drivers/LPC824/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_reset.c fsl_swm.c fsl_syscon.c fsl_usart.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m0/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group starup
    ./: IAR_cstartup_M.s
  group user
    ../Src/: board.c clock_config.c main.c sys_init.c system_LPC824.c usart.c
