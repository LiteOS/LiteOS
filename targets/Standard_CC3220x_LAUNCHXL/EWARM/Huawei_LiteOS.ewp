# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC3220SF TexasInstruments CC3220SF
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: DeviceFamily_CC3220; LOS_KERNEL_DEBUG_OUT; _DLIB_FILE_DESCRIPTOR; ewarm
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Core\Include; ..\Inc; ..\..\..\components\cmsis; ..\..\..\components\cmsis\1.0; ..\..\..\components\cmsis\2.0; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\examples\include; ..\..\..\kernel\extended\include; ..\Drivers; ..\Drivers\ti\devices\cc32xx; ..\dpl
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: CC3220SF_LAUNCHXL_LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group dpl
    ../dpl/: ClockPSysTick_nortos.c DebugP_nortos.c HwiPCC32XX_nortos.c MutexP_nortos.c posix_sleep.c PowerCC32XX_nortos.c QueueP_nortos.c SemaphoreP_nortos.c SwiP_nortos.c SystemP_nortos.c
  group Drivers/CC3220x_Device
    ../Drivers/ti/devices/cc32xx/driverlib/: cpu.c flash.c gpio.c interrupt.c pin.c prcm.c systick.c timer.c uart.c utils.c
  group Drivers/CC3220x_Driver
    ../Drivers/ti/drivers/gpio/: GPIOCC32XX.c
    ../Drivers/ti/drivers/utils/: List.c RingBuf.c
    ../Drivers/ti/drivers/power/: PowerCC32XX.c PowerCC32XX_asm.asm
    ../Drivers/ti/drivers/uart/: UARTCC32XX.c
    ../Drivers/ti/drivers/: UARTx.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group starup
    ./: startup_cc32xx_iar.c
  group user
    ../Src/: CC3220SF_LAUNCHXL.c main.c sys_init.c system_cc32xx.c usart.c
