# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746ZG ST STM32F746ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx; LOS_KERNEL_DEBUG_OUT; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pe177,Pe181,Pe186,Pe223
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\Inc; ..\..\..\components\cmsis; ..\..\..\components\cmsis\1.0; ..\..\..\components\cmsis\2.0; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\..\..\kernel\extended\include; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\arch\arm\arm-m\cortex-m7; ..\..\..\examples\include; ..\Drivers\STM32F7xx_HAL_Driver\Inc; ..\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy; ..\..\..\arch\arm\common\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.hex
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: STM32F746ZG-LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c
  group examples
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m7/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group starup
    ./: los_startup_iar.s
  group user
    ../Src/: main.c sys_init.c system_stm32f7xx.c usart.c
