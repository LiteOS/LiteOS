# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS +hex
  AfterMake: $KARM\ARMCC\bin\fromelf.exe  --bin -o ./Objects/Huawei_LiteOS.bin ./Objects/Huawei_LiteOS.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F103xE,NDEBUG,USE_BOOTLOADER
  c misc: --diag_suppress=1,47,177,186,223,1295
  c include: ..\Inc;..\OS_CONFIG;..\..\..\arch\arm\common\cmsis;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\Hardware\Inc;..\..\..\components\fota\ota;..\..\..\components\fota\utility
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ./: startup_stm32f103xe.s
  group user
    ../Src/: usart.c system_stm32f1xx.c board.c bootloader_main.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_dma.c
  group Hardware
    ../Hardware/Src/: hal_spi_flash.c hal_flash.c
  group fota
    ../../../components/fota/ota/: ota.c ota_default.c
    ../../../components/fota/utility/: ota_crc.c ota_sha256.c
software components: CMSIS:CORE 5.1.1
