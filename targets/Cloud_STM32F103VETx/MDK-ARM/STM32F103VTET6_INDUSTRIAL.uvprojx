# Keil uVision project STM32F103VTET6_INDUSTRIAL.uvprojx, settings and files
target STM32F103VTET6_INDUSTRIAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32F103VTET6_INDUSTRIAL
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,WITH_AT_FRAMEWORK,USE_NB_NEUL95,STM32F103xE,LWM2M_BOOTSTRAP
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\arch\arm\arm-m\include;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\kernel\include;..\OS_CONFIG;..\..\..\components\connectivity\nb_iot;..\..\..\components\connectivity\at_frame;..\..\..\drivers\devices\nb;..\..\..\components\connectivity\agent_tiny\osadapter;..\..\..\include;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\connectivity\lwm2m\examples\client;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\net\lwip\lwip_port;..\..\..\components\net\lwip\lwip_port\OS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group LiteOS/Arch
    ../../../arch/arm/arm-m/cortex-m3/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group LiteOS/CMSIS
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
  group AT_Frame USE NB_IOT_BC95
    ../../../components/connectivity/nb_iot/: los_nb_api.c
    ../../../components/net/at_frame/: at_main.c at_api.c
    ../../../components/net/at_device/nb_bc95/: bc95.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c
  group Application/User
    ../Src/: main.c stm32f1xx_it.c usart.c stm32f1xx_hal_msp.c gpio.c at_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f1xx.c
  group atiny_demo
    ../../../demos/agenttiny_lwm2m/: agent_tiny_cmd_ioctl.c agent_tiny_demo.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
  group os_depends
    ../../../osdepends/liteos/: atiny_osdep.c
  group atiny_tiny
    ../../../components/connectivity/agent_tiny/atiny_lwm2m/: agenttiny.c atiny_rpt.c connection.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c util_timer.c
  group atiny_dep
    ../../../components/net/sal/: atiny_socket.c
  group lwip
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../../../components/net/lwip/lwip_port/OS/: ethernetif.c sys_arch.c
software components: CMSIS:CORE 4.3.0
