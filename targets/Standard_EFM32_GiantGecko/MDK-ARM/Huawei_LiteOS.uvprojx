# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: EFM32GG990F1024 Silicon Labs
  pack: SiliconLabs.EFM32GG_DFP.5.5.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EFM32_Pearl_Gecko
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: EFM32GG990F1024,RETARGET_USART
  c misc: --diag_suppress=1215
  c include: ..\..\..\arm\arm-m\include;..\..\..\arm\arm-m\cortex-m4\keil;..\..\..\arm\arm-m\include;..\..\..\kernel\base\include;..\..\..\kernel\base\core;..\..\..\kernel\extended\include;..\..\..\kernel\include;..\Drivers\inc;..\Inc;..\OS_CONFIG;..\Drivers\kit_drivers;..\Drivers\config;..\..\..\arch\arm\arm-m\include;..\Drivers\efm32gg990f1024_config;..\Drivers\efm32gg990f1024_driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./: startup_efm32gg.s
  group user
    ../Src/: usart.c main.c sys_init.c system_efm32gg.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/: los_init.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group driver
    ../Drivers/kit_drivers/: retargetio.c retargetserial.c
  group Drivers
    ../Drivers/efm32gg990f1024_driver/src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_core.c em_cryotimer.c em_crypto.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpcrc.c em_gpio.c em_i2c.c em_idac.c em_int.c em_lcd.c em_ldma.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_rtcc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
software components: CMSIS:CORE 5.1.1
