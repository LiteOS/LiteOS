<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Standard_STM32F0Discovery.ewp</path>
  </project>
  <batchBuild />
</workspace>
