# IAR project Huawei_LiteOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKW41Z512xxx4 NXP MKW41Z512xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKW41Z512VHT4; FRDM_KW41Z; FREEDOM; LOS_KERNEL_DEBUG_OUT; _DLIB_FILE_DESCRIPTOR; ARM_MATH_CM0PLUS
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167,Pe181,Pe186,Pe177,Pe223
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\Inc; ..\..\..\components\cmsis; ..\..\..\components\cmsis\1.0; ..\..\..\components\cmsis\2.0; ..\..\..\kernel\base\include; ..\..\..\kernel\include; ..\OS_CONFIG; ..\..\..\arch\arm\arm-m\include; ..\..\..\examples\include; ..\Drivers\MKW41Z512xxx4; ..\..\..\kernel\extended\include; ..\..\..\arch\arm\common\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Huawei_LiteOS.srec
  ILINK.IlinkOutputFile: Huawei_LiteOS.out
  ILINK.IlinkIcfFile: MKW41Z512xxx4_LiteOS.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Drivers/MKW41Z512xxx4
    ../Drivers/MKW41Z512xxx4/: fsl_clock.c fsl_common.c fsl_flash.c fsl_gpio.c fsl_lptmr.c fsl_lpuart.c fsl_sim.c fsl_smc.c
  group examples
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m0/iar/: los_dispatch_iar.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/: los_init.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group starup
    ./: startup_MKW41Z4.s
  group user
    ../Src/: board.c clock_config.c fsl_debug_console.c main.c pin_mux.c system_MKW41Z4.c
