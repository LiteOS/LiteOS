# Keil uVision project FM33A0XX_Tester.uvprojx, settings and files
target Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.2.02
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: FM33A0XX_Tester
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __VTOR_PRESENT,__A04,__DEBUG
  c include: .\Drivers;.\UserCode;.\Device\Include;..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\extended\include;..\..\arch\arm\arm-m\include;..\..\arch\arm\arm-m\cortex-m0;.\OS_CONFIG;..\..\examples\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\sct\fm33a0_test.sct
  group UserCode
    ./UserCode/: main.c print.c user_init.c los_uart.c ring.c neul_bc95.c dht12.c
  group stdperiph_driver
    ./Drivers/: fm33a0xx_aes.c fm33a0xx_anac.c fm33a0xx_btim.c fm33a0xx_crc.c fm33a0xx_dma.c fm33a0xx_etim.c fm33a0xx_flash.c fm33a0xx_gpio.c fm33a0xx_hspi.c fm33a0xx_i2c.c fm33a0xx_iwdt.c fm33a0xx_lcd.c fm33a0xx_lptim.c fm33a0xx_pmu.c fm33a0xx_rcc.c fm33a0xx_rtc.c fm33a0xx_scu.c fm33a0xx_spi.c fm33a0xx_trng.c fm33a0xx_u7816.c fm33a0xx_uart.c fm33a0xx_wwdt.c
  group liteos/kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../kernel/base/mem/common/: los_memstat.c los_slab.c los_slabmem.c los_memcheck.c
    ../../kernel/base/misc/: los_misc.c
    ../../kernel/extended/tickless/: los_tickless.c
    ../../kernel/: los_init.c
    ../../kernel/base/om/: los_err.c
    ../../kernel/base/mem/membox/: los_membox.c
  group liteos/arch
    ../../arch/arm/arm-m/cortex-m0/keil/: los_dispatch_keil.S
    ../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group examples
    ../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
target Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: FM33A04XX FMSH
  pack: Keil.FM33A0XX_DFP.0.2.02
  cpu: as above
  output: FM33A0XX_Tester
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: __VTOR_PRESENT,__A04
  c include: ..\Drivers;..\UserCode
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\sct\fm33a0_test.sct
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
