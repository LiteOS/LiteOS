# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (ARM-ADS)
  device: LPC51U68JBD64 NXP
  pack: NXP.LPC51U68_DFP.10.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS +hex
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x0)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_LWIP,WITH_DTLS
  c misc: --library_interface=armcc --library_type=standardlib  --diag_suppress=66,1296,186
  c include: ..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m0;..\..\..\examples\include;..\..\..\test\include;..\..\..\components\net\lwip-2.0.3\src\include;..\..\..\components\net\lwip_port;..\..\..\components\net\lwip_port\OS;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\connectivity\lwm2m\examples\client;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include\mbedtls;..\..\..\components\connectivity\agent_tiny\comm\include;..\..\..\components\connectivity\agent_tiny\lwm2m_client;..\..\..\components\connectivity\agent_tiny\examples;..\..\..\components\connectivity\agent_tiny\osadapter;..\..\..\components\connectivity\at_frame;..\..\..\drivers\devices\wifi;..\..\..\drivers\devices\gprs;..\..\..\drivers\devices\nb;..\..\..\components\connectivity\nb_iot;..\..\..\components\fota\fota_package_storage_device;..\..\..\components\fota\ota;..\..\..\components\fota\utility;..\..\..\components\connectivity\agent_tiny\firmware_update;..\..\..\components\connectivity\agent_tiny\lwm2m_client\fota;..\board;..\cmsis;..\startup;..\utilities;..\drivers;..\user;..\utilities;..\stupid;..\..\..\examples\include;..\..\..\kernel\base\mem\common;..\..\..\components\net\ppp_port\osport;..\..\..\components\connectivity\lwm2m\examples\shared
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: ../libs/keil_lib_power.lib
--remove
  group startup
    ../startup/: los_startup_keil.S
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m0/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group lwip
    ../../../components/net/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.0.3/src/core/ipv4/: ip4_frag.c ip4_addr.c ip4.c igmp.c icmp.c etharp.c dhcp.c autoip.c
    ../../../components/net/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../../../components/net/lwip_port/OS/: sys_arch.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group er-coap
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
  group os_adapter
    ../../../components/connectivity/agent_tiny/osadapter/: atiny_adapter.c atiny_socket.c
  group atiny_tiny
    ../../../components/connectivity/agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c atiny_rpt.c connection.c
    ../../../components/connectivity/agent_tiny/firmware_update/: firmware_update.c
    ../../../components/connectivity/agent_tiny/lwm2m_client/fota/: atiny_fota_manager.c atiny_fota_state.c atiny_update_info.c
  group at_framework
    ../../../components/connectivity/at_frame/: at_api_interface.c atadapter.c
  group nb_iot_api
    ../../../components/connectivity/nb_iot/: los_nb_api.c
  group user
    ../user/: ENC28J60.c ENC28J60.h ethernetif.c led.c main.c sys_init.c uart.c fota_port.c fota_port.h sys_init.h hal_spi_flash.h
  group board
    ../board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group cmsis
    ../cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0plus.h fsl_device_registers.h LPC51U68.h LPC51U68_features.h mpu_armv7.h system_LPC51U68.c system_LPC51U68.h
  group utilities
    ../utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group fota
    ../../../components/fota/ota/: ota.c ota_default.c
    ../../../components/fota/fota_package_storage_device/: fota_firmware_writer.c fota_package_checksum.c fota_package_head.c fota_package_storage_device.c
    ../../../components/fota/utility/: ota_crc.c ota_sha256.c
  group config
    ../OS_CONFIG/: coap_config.h los_builddef.h los_printf.h lwipopts.h target_config.h los_mbedtls_config.h los_mbedtls_config_psk.h timing_alt.h
  group examples
    ../../../examples/api/: los_api_dynamic_mem.c los_api_event.c los_api_interrupt.c los_api_list.c los_api_msgqueue.c los_api_mutex.c los_api_sem.c los_api_static_mem.c los_api_systick.c los_api_task.c los_api_timer.c los_demo_entry.c los_inspect_entry.c
  group drivers
    ../drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flexcomm.c fsl_flexcomm.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_iocon.h fsl_power.c fsl_power.h fsl_reset.c fsl_reset.h fsl_spi.c fsl_spi.h fsl_usart.c fsl_usart.h
  group ppp
    ../../../components/net/lwip-2.0.3/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
    ../../../components/net/lwip-2.0.3/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group pppport
    ../../../components/net/ppp_port/ppppos/: atcmd.c demo.c
    ../../../components/net/ppp_port/osport/: iodev.c kernel.c osport.h ring.c
  group agent_demo
    ../../../components/connectivity/agent_tiny/examples/: agent_tiny_cmd_ioctl.c agent_tiny_cmd_ioctl.h agent_tiny_demo.c agent_tiny_demo.h
software components: CMSIS:CORE 5.1.1
