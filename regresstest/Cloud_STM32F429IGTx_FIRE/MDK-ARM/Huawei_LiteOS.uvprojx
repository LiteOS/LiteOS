# Keil uVision project Huawei_LiteOS.uvprojx, settings and files
target HuaweiLiteOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Huawei_LiteOS
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<los_mbedtls_config.h>,LWM2M_LITTLE_ENDIAN,LWM2M_CLIENT_MODE,NDEBUG,WITH_LWIP,CONFIG_FEATURE_FOTA,__LITEOS__
  c misc: --diag_suppress=1,47,177,186,223,1294,1295
  c include: ..\..\..\targets\Cloud_STM32F429IGTx_FIRE\Inc;..\..\..\components\cmsis;..\..\..\components\cmsis\1.0;..\..\..\components\cmsis\2.0;..\..\..\kernel\base\include;..\..\..\kernel\include;..\..\..\kernel\extended\include;..\..\..\targets\Cloud_STM32F429IGTx_FIRE\OS_CONFIG;..\..\..\arch\arm\arm-m\include;..\..\..\arch\arm\arm-m\cortex-m4;..\..\..\examples\include;..\..\..\test\include;..\..\..\targets\Cloud_STM32F429IGTx_FIRE\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\targets\Cloud_STM32F429IGTx_FIRE\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;..\..\..\components\net\lwip-2.0.3\src\include;..\..\..\components\net\lwip_port;..\..\..\components\net\lwip_port\OS;..\..\..\components\connectivity\lwm2m\core\er-coap-13;..\..\..\components\connectivity\lwm2m\core;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\connectivity\lwm2m\examples\client;..\..\..\components\security\mbedtls\mbedtls_port;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include;..\..\..\components\security\mbedtls\mbedtls-2.6.0\include\mbedtls;..\..\..\components\connectivity\agent_tiny\comm\include;..\..\..\components\connectivity\agent_tiny\lwm2m_client;..\..\..\components\connectivity\agent_tiny\examples;..\..\..\components\connectivity\agent_tiny\osadapter;..\..\..\targets\Cloud_STM32F429IGTx_FIRE\Hardware\Inc;..\..\..\components\connectivity\at_frame;..\..\..\drivers\devices\wifi;..\..\..\drivers\devices\gprs;..\..\..\drivers\devices\nb;..\..\..\components\connectivity\nb_iot;..\..\..\components\fota\fota_package_storage_device;..\..\..\components\fota\ota;..\..\..\components\connectivity\agent_tiny\firmware_update;..\..\..\components\fota\utility;..\..\..\components\connectivity\agent_tiny\lwm2m_client\fota;..\..\..\components\net\ppp_port\osport;..\..\..\components\connectivity\lwm2m\examples\shared;..\..\..\components\fs\include;..\..\..\components\fs\jffs2;..\..\..\components\fs\jffs2\src;..\..\..\components\fs\jffs2\port;..\..\..\components\fs\fatfs\ff13b\source;..\..\..\components\fs\spiffs\spiffs_git\src;..\..\..\components\fs\spiffs\spiffs_git\src\default;..\..\..\targets\Cloud_STM32F429IGTx_FIRE\Inc
  asm misc: --diag_suppress=A1581W
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\STM32F429IGTx-LiteOS.sct
  group startup
    ./: los_startup_keil.s
  group user
    ../../../targets/Cloud_STM32F429IGTx_FIRE/Src/: at_hal.c dwt.c eth.c fota_port.c sys_init.c system_stm32f4xx.c usart.c spiffs_stm32f4xx.c fatfs_stm32f4xx.c jffs2_stm32f4xx.c
    ../Src/: test_main.c
  group drivers
    ../../../drivers/devices/gprs/: sim900a.c
    ../../../drivers/devices/nb/: bc95.c
    ../../../drivers/devices/wifi/esp8266/: esp8266.c
  group liteos/cmsis
    ../../../components/cmsis/: cmsis_liteos.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_slab.c los_slabmem.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/: los_init.c
    ../../../kernel/extended/tickless/: los_tickless.c
  group liteos/arch
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
  group Drivers/STM32F4xx_HAL_Driver
    ../../../targets/Cloud_STM32F429IGTx_FIRE/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group hardware
    ../../../targets/Cloud_STM32F429IGTx_FIRE/Hardware/Src/: hal_flash.c hal_iwdg.c hal_rng.c hal_spi_flash.c
  group lwip
    ../../../components/net/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.0.3/src/core/ipv4/: ip4_frag.c ip4_addr.c ip4.c igmp.c icmp.c etharp.c dhcp.c autoip.c
    ../../../components/net/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip-2.0.3/src/netif/: ethernet.c
  group lwip_port
    ../../../components/net/lwip_port/OS/: ethernetif.c sys_arch.c
  group mbedtls
    ../../../components/security/mbedtls/mbedtls-2.6.0/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c ripemd160.c rsa.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_port
    ../../../components/security/mbedtls/mbedtls_port/: dtls_interface.c entropy_hardware_poll.c net_sockets_alt.c timing_alt.c
  group er-coap
    ../../../components/connectivity/lwm2m/core/er-coap-13/: er-coap-13.c
  group lwm2m
    ../../../components/connectivity/lwm2m/core/: block1.c bootstrap.c data.c discover.c json.c liblwm2m.c list.c management.c objects.c observe.c packet.c registration.c tlv.c transaction.c uri.c utils.c
    ../../../components/connectivity/lwm2m/examples/shared/: commandline.c
  group os_adapter
    ../../../components/connectivity/agent_tiny/osadapter/: atiny_adapter.c atiny_socket.c
  group atiny_tiny
    ../../../components/connectivity/agent_tiny/lwm2m_client/: agenttiny.c atiny_log.c object_access_control.c object_binary_app_data_container.c object_connectivity_moni.c object_connectivity_stat.c object_device.c object_firmware.c object_location.c object_security.c object_server.c platform_adapter.c atiny_rpt.c connection.c
    ../../../components/connectivity/agent_tiny/firmware_update/: firmware_update.c
    ../../../components/connectivity/agent_tiny/lwm2m_client/fota/: atiny_fota_manager.c atiny_fota_state.c atiny_update_info.c
  group agent_demo
    ../../../components/connectivity/agent_tiny/examples/: agent_tiny_demo.c agent_tiny_cmd_ioctl.c
  group at_framework
    ../../../components/connectivity/at_frame/: at_api_interface.c atadapter.c
  group nb_iot_api
    ../../../components/connectivity/nb_iot/: los_nb_api.c
  group fota
    ../../../components/fota/ota/: ota.c ota_default.c
    ../../../components/fota/utility/: ota_crc.c ota_sha256.c
    ../../../components/fota/fota_package_storage_device/: fota_firmware_writer.c fota_package_head.c fota_package_storage_device.c fota_package_checksum.c
  group ppp
    ../../../components/net/lwip-2.0.3/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c ecp.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppos.c upap.c utils.c vj.c
    ../../../components/net/lwip-2.0.3/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c sha1.c
  group pppport
    ../../../components/net/ppp_port/osport/: iodev.c kernel.c osport.h ring.c
    ../../../components/net/ppp_port/ppppos/: atcmd.c demo.c
  group lib
    ../../../components/lib/libc/: malloc.c
  group vfs
    ../../../components/fs/vfs/: los_vfs.c
  group spiffs
    ../../../components/fs/spiffs/: los_spiffs.c
    ../../../components/fs/spiffs/spiffs_git/src/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
  group fatfs
    ../../../components/fs/fatfs/: los_fatfs.c
    ../../../components/fs/fatfs/ff13b/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group jffs2
    ../../../components/fs/jffs2/: los_jffs2.c
    ../../../components/fs/jffs2/src/: jffs2_build.c jffs2_compr.c jffs2_compr_rtime.c jffs2_compr_rubin.c jffs2_compr_zlib.c jffs2_debug.c jffs2_dir.c jffs2_erase.c jffs2_fs.c jffs2_gc.c jffs2_malloc.c jffs2_nodelist.c jffs2_nodemgmt.c jffs2_rbtree.c jffs2_read.c jffs2_readinode.c jffs2_scan.c jffs2_write.c
    ../../../components/fs/jffs2/port/: jffs2_flashio.c jffs2_gcthread.c jffs2_os.c jffs2_port.c jffs2_slab.c jffs2_spinlock.c jffs2_wait.c
  group cyg
    ../../../components/fs/jffs2/cyg/crc/: crc32.c
    ../../../components/fs/jffs2/cyg/compress/: adler32.c compress.c deflate.c inffast.c inflate.c inftrees.c trees.c zutil.c
  group cmockery
    ../../cmockery/src/: cmockery.c
  group test_suit
    ../../test_suit/: agenttiny_test.c fs_test.c
software components: CMSIS:CORE 5.0.1
